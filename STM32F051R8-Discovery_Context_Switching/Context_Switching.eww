<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Context_Switching.ewp</path>
    </project>
    <batchBuild />
</workspace>
